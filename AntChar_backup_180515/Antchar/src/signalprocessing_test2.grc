<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gr_antenna</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>FIR_decimation</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>auto_loop</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_freq</value></param>
<param><key>value</key><value>96.1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_freq</value></param>
<param><key>value</key><value>c_freq+0.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_in_mhz</value></param>
<param><key>value</key><value>(c_freq+0.5e6)/1.0e6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>choos</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label0</key><value>sdr</value></param>
<param><key>label1</key><value>null</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>9.1e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>loop</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lowpasstaps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, samp_rate, cutoff,transition, 120,firdes.WIN_BLACKMAN, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>number_of_taps_FIR</value></param>
<param><key>value</key><value>len(lowpasstaps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>select</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-500e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>antchar_E_field_calc_ff</key>
<param><key>id</key><value>antchar_E_field_calc_ff_0</value></param>
<param><key>freq</key><value>(c_freq+0.5e6)/1.0e6</value></param>
</block>
<block>
<key>antchar_antenna_polarization_adder_ff</key>
<param><key>id</key><value>antchar_antenna_polarization_adder_ff_0</value></param>
</block>
<block>
<key>antchar_dbm_correction_py_ff</key>
<param><key>id</key><value>antchar_dbm_correction_py_ff_0</value></param>
<param><key>freq</key><value>(c_freq+0.5e6)/1.0e6</value></param>
</block>
<block>
<key>antchar_select_ff</key>
<param><key>id</key><value>antchar_select_ff_0</value></param>
<param><key>select</key><value>select</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>blocks_max_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
<param><key>vlen_out</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1.0/float(fft_size)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>fft_size</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_size)</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>FIR_decimation</value></param>
<param><key>taps</key><value>lowpasstaps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>500e3</value></param>
<param><key>decim</key><value>FIR_decimation</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>lowpasstaps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>c_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value>airspy</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>avg</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>-150</value></param>
<param><key>name</key><value>"Measured dBm"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>avg</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>-150</value></param>
<param><key>name</key><value>"Corrected dBm"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>-150</value></param>
<param><key>name</key><value>"Polarisation adder dBmW/m²"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1</value></param>
<param><key>ymin</key><value>-200</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>antchar_E_field_calc_ff_0</source_block_id><sink_block_id>antchar_antenna_polarization_adder_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>antchar_antenna_polarization_adder_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>antchar_antenna_polarization_adder_ff_0</source_block_id><sink_block_id>qtgui_number_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>antchar_dbm_correction_py_ff_0</source_block_id><sink_block_id>antchar_E_field_calc_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>antchar_dbm_correction_py_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>antchar_select_ff_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0</source_block_id><sink_block_id>antchar_dbm_correction_py_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_max_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>antchar_select_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>antchar_select_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
